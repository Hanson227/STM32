# Keil uVision project project.uvprojx, settings and files
target demo (ARM-ADS)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\;.\user
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group user
    ./: main.c
    ./user/delay/: delay.c
    ./user/HCSR/: hcsr.c
    ./user/iwdg/: iwdg.c
    ./user/led/: led.c
    ./user/usart/: usart.c
    ./user/tim/: tim.c
    ./user/blue/: blue.c
    ./user/wenshi/: wenshi.c
    ./user/key/: key.c
    ./user/rtc/: rtc.c
    ./user/infrared/: infrared.c
    ./user/flash/: flash.c
    ./user/handler/: handler.c
    ./user/ADC/: adc.c
    ./user/flame/: flame.c
    ./user/steering/: steering.c
    ./user/DAC/: dac.c
    ./user/SPI/: spi.c
    ./user/rc522/: rc522.c
    ./user/i2c/: i2c.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.3.1, Device:StdPeriph Drivers:ADC 1.3.0, Device:StdPeriph Drivers:DAC 1.3.0, Device:StdPeriph Drivers:EXTI 1.3.0, Device:StdPeriph Drivers:Flash 1.3.0, Device:StdPeriph Drivers:Framework 1.3.1, Device:StdPeriph Drivers:GPIO 1.3.0, Device:StdPeriph Drivers:IWDG 1.3.0, Device:StdPeriph Drivers:PWR 1.3.0, Device:StdPeriph Drivers:RCC 1.3.0, Device:StdPeriph Drivers:RTC 1.3.0, Device:StdPeriph Drivers:SPI 1.3.0, Device:StdPeriph Drivers:SYSCFG 1.3.0, Device:StdPeriph Drivers:TIM 1.3.0, Device:StdPeriph Drivers:USART 1.3.0, Device:StdPeriph Drivers:WWDG 1.3.0
